# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLib\inc;..\HARDWARE\LED;..\HARDWARE\grayScaleSensor;..\HARDWARE\gyro;..\HARDWARE\uart;..\HARDWARE\can;..\HARDWARE\motor3508;..\HARDWARE\pid;..\HARDWARE\key;..\HARDWARE\chassis;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\linetracker;..\HARDWARE\lineTracker_linearRegression
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/grayScaleSensor/: grayScaleSensor.c
    ../HARDWARE/gyro/: gyro.c
    ../HARDWARE/uart/: cycleArray.c uart.c
    ../HARDWARE/can/: can.c
    ../HARDWARE/motor3508/: motor3508.c
    ../HARDWARE/pid/: pid.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/chassis/: chassis.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/linetracker/: linetracker.c
    ../HARDWARE/lineTracker_linearRegression/: lineTracker_linearRegression.c
